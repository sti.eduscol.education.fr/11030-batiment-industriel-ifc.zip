Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2019-04-09T17:06:02
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.1.0.0 - Interface alternative d'export 18.1.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Apr 09 17:06:02 2019 * Host: pcjulien * Database: C:\Users\julien\AppData\Local\Temp\{BBF6DAC3-3ABF-4450-8749-6E4B4CED65E3}\ifc * Database version: 5507 * Database creation date: Tue Apr 09 17:05:41 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Apr 09 17:05:44 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Apr 09 17:05:44 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 48, 52, 0, 117187; RefLongitude: 2, 19, 59, 880409; RefElevation: 0 m

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Niveau 0
LongName: Niveau 0; Elevation: -1.94916e-14 m

# IfcBeam: Cornière à ailes égales:L50x5 (22)
In: Niveau 0
Type - PredefinedType: BEAM
Material: Platelage métallique
Pset_BeamCommon - LoadBearing: yes; IsExternal: no; Reference: L50x5
Name (Cornière à ailes égales:L50x5:...) | Slope (deg)
244658 | 39.3026
244660 | 39.3026
244662 | 39.3026
244664 | 39.3026
244666 | 10.2603
244668 | 10.2603
244670 | 10.2603
244672 | 10.2603
244674 | 10.2603
244676 | 10.2603
244678 | 10.2603
244680 | 10.2603
244682 | 10.2603
244684 | 10.2603
244686 | 10.2603
244688 | 10.2603
244690 | 0
244692 | 0
244694 | 0
244713 | 0
244715 | 0
244717 | 0

# IfcBeam: HE-A:HEA160 (22)
In: Niveau 0
Type - PredefinedType: BEAM
Material: Platelage métallique
Pset_BeamCommon - Reference: HEA160; LoadBearing: yes; IsExternal: no
Name (HE-A:HEA160:...) | Slope (deg)
244502 | 24.4336
244504 | 24.4336
244512 | 24.4336
244514 | 24.4336
244520 | 24.4336
244522 | 24.4336
244528 | 24.4336
244530 | 24.4336
244536 | 24.4336
244538 | 24.4336
244544 | 24.4336
244546 | 24.4336
244548 | 0
244550 | 0
244552 | 0
244554 | 0
244556 | 0
244648 | 0
244650 | 0
244652 | 0
244654 | 0
244656 | 0

# IfcBeam: IPE:IPE120 (40)
In: Niveau 0
Type - PredefinedType: BEAM
Material: Platelage métallique
Pset_BeamCommon - LoadBearing: yes; IsExternal: no; Slope: 0 deg; Reference: IPE120
Name (IPE:IPE120:...)
244558
244560
244562
244564
244566
244568
244570
244572
244574
244576
244578
244580
244582
244584
244586
244588
244590
244592
244594
244596
244608
244610
244612
244614
244616
244618
244620
244622
244624
244626
244628
244630
244632
244634
244636
244638
244640
244642
244644
244646

# IfcColumn: HEA160 (16)
In: Niveau 0
Type - ElementType: HEA160; PredefinedType: COLUMN
Material: Platelage métallique
Pset_ColumnCommon - Reference: HEA160; LoadBearing: yes; IsExternal: no
Name (Poteau HE-A:HEA160:...)
244497 | Pset_ColumnCommon - Slope: 0 deg
244500
244506
244510
244516
244518
244524
244526
244532
244534
244540
244542
244696 | Pset_ColumnCommon - Slope: 0 deg
244710
244719
244721
